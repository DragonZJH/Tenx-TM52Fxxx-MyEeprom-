# Keil uVision project FE8276.uvproj, settings and files
target Target 1 (MCS-51)
  device: TM52FE8273B tenx
  cpu: IRAM(0-0xFF) CLOCK(16000000) XRAM(0xFD00-0xFFFF)
  output: MyEepromTest +hex
  c flags: Optimize=9
  c include: .\Drivers
  group Source Group 1
    ./: STARTUP_TENX52.A51 MAIN_FHQ.c DEFINE.c Delay.c LED.c Uart.c MyEeprom.c TM52F82XX_Eeprom.c
